VAR_GLOBAL
	fX_Scope	: LREAL;
	fY_Scope	: LREAL;
	fW_Scope	: LREAL;
END_VAR
